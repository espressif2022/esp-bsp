## examples/display_lvgl_HHK5/main/Kconfig.projbuild
```kconfig
menu "Example Configuration"

    config EXAMPLE_ENABLE_FILE_SYSTEM_APPEND
            bool "File system append"
endmenu
```
